* MXR Distortion+ Clipping Stage
* Diode Clipping Circuit for Validation
* Generated by SpiceValidator

.model 1N4148 D(IS=1.4e-14 N=1.06 RS=0.25)

* Circuit Components
Vsrc 1 0 PWL(0 0 0.001 0.1 0.005 -0.1 0.01 0)  * Triangle wave
Rsrc 1 2 1000
* Back-to-back diodes (symmetric clipping)
D1 2 3 1N4148
D2 3 2 1N4148
Rload 3 0 100000

.tran 0 0.01 0 1e-6
.control
run
set wr_vecnames
option numdgt=7
wrdata mxr_output.txt time v(2) v(3)
quit
.endc
.end
